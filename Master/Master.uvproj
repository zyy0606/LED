# Keil uVision project Master.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Master +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0xx
  c include: .\FWlib\inc;.\User;.\FWlib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MDK-ARM
    ./: startup_stm32f030.s
  group User
    ./User/: main.c stm32f0xx_it.c usart.c rtc.c
  group FWlib
    ./FWlib/src/: stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_gpio.c stm32f0xx_pwr.c stm32f0xx_misc.c
    ./FWlib/: system_stm32f0xx.c
