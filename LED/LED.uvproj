# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030K6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: LED +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0xx
  c include: .\FWlib\inc;.\User;.\FWlib
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group MDK-ARM
    ./: startup_stm32f030.s
  group User
    ./User/: adc.c gpio.c stm32f0xx_it.c main.c pwm.c soc.c usart.c
  group FWlib
    ./FWlib/src/: stm32f0xx_adc.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_dma.c stm32f0xx_rtc.c stm32f0xx_pwr.c stm32f0xx_usart.c stm32f0xx_misc.c
    ./FWlib/: system_stm32f0xx.c
